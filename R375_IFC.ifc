Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-06-03T11:06:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190507_1515(x64) - Exporter 17.0.517.0 - Alternate UI 17.15.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 03 11:06:45 2020 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{4A5E1CAA-87AC-429B-82DD-287044CC394F}\ifc * Database version: 5507 * Database creation date: Wed Jun 03 11:06:39 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 03 11:06:39 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 03 11:06:39 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowController: Brushed Stainless Steel, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R375:Brushed Stainless Steel:305265
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_BrushedStainlessSteel
Pset_ManufacturerTypeInformation - ModelReference: Brushed Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Matte Black, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R375:Matte Black:305281
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_MatteBlack
Pset_ManufacturerTypeInformation - ModelReference: Matte Black; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Polished Stainless Steel, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R375:Polished Stainless Steel:305296
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_Polished
Pset_ManufacturerTypeInformation - ModelReference: Polished Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a
